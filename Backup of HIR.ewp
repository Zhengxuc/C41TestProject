# IAR project Backup of HIR.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F169 MSP430F169
  General.GStackSize2: 200
  General.GHeapSize2: 80
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  group (top)
    ./: ad.cpp ad.h AD421.cpp AD421.h Alarm.c Alarm.h CurveFitting.c CurveFitting.h delay.cpp delay.h Device.H Dis_lib.h DisDataCalculate.c DisDataCalculate.h FittingData.h Flash_RW.cpp Flash_RW.h hart.c Hart.h HT1621.cpp HT1621.H KEYBOARD.cpp KEYBOARD.H Limited.h main.c MessageCenter.cpp MessageCenter.h Pwm.c Pwm.h RunAuto.c RunAuto.h RunConfig.c RunConfig.H RunMen.c RunMen.H Tick.cpp Tick.h Uart.c Uart.h
